# Keil uVision project intelligent-spoon.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: intelligent-spoon +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\mcu_sdk;.\system
  group SYSTEM
    ./system/: main.c
  group SDK
    ./mcu_sdk/: mcu_api.c protocol.c system.c
